v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 270 160 300 160 {lab=VDD}
N -360 -20 -180 -20 {lab=VDD}
N -180 -20 -180 20 {lab=VDD}
N -180 -20 -10 -20 {lab=VDD}
N -10 -20 -10 20 {lab=VDD}
N -10 -20 170 -20 {lab=VDD}
N 270 -20 270 90 {lab=VDD}
N 300 90 300 160 {lab=VDD}
N 270 90 300 90 {lab=VDD}
N -10 50 30 50 {lab=VDD}
N 30 -20 30 50 {lab=VDD}
N -220 50 -180 50 {lab=VDD}
N -220 -20 -220 50 {lab=VDD}
N -100 50 -100 100 {lab=#net1}
N -180 120 -100 120 {lab=#net1}
N -360 210 60 210 {lab=Vin+}
N 60 210 60 280 {lab=Vin+}
N 30 280 60 280 {lab=Vin+}
N -180 310 -180 340 {lab=#net2}
N -180 340 -10 340 {lab=#net2}
N -10 310 -10 340 {lab=#net2}
N -180 280 -10 280 {lab=VSS}
N -140 50 -50 50 {lab=#net1}
N -60 580 170 580 {lab=VSS}
N -300 280 -220 280 {lab=OUT}
N -320 280 -300 280 {lab=OUT}
N -110 530 -110 580 {lab=VSS}
N -110 500 -90 500 {lab=VSS}
N -90 500 -90 550 {lab=VSS}
N -110 550 -90 550 {lab=VSS}
N -280 580 -60 580 {lab=VSS}
N -180 500 -150 500 {lab=Iref}
N -210 500 -180 500 {lab=Iref}
N -250 530 -250 580 {lab=VSS}
N -270 500 -250 500 {lab=VSS}
N -270 500 -270 550 {lab=VSS}
N -270 550 -250 550 {lab=VSS}
N -10 160 50 160 {lab=#net3}
N -180 450 -180 500 {lab=Iref}
N -250 450 -180 450 {lab=Iref}
N -380 450 -250 450 {lab=Iref}
N -250 450 -250 470 {lab=Iref}
N -250 420 -250 450 {lab=Iref}
N 270 190 270 220 {lab=OUT}
N 230 -20 270 -20 {lab=VDD}
N 190 160 230 160 {lab=#net3}
N 190 160 190 230 {lab=#net3}
N 270 450 270 580 {lab=VSS}
N 230 580 270 580 {lab=VSS}
N 270 420 290 420 {lab=VSS}
N 290 420 290 480 {lab=VSS}
N 270 480 290 480 {lab=VSS}
N -480 650 280 650 {lab=OUT}
N -480 280 -480 650 {lab=OUT}
N -480 280 -320 280 {lab=OUT}
N -110 380 -110 470 {lab=#net2}
N 370 310 370 640 {lab=OUT}
N 250 230 270 230 {lab=OUT}
N 190 230 210 230 {lab=#net3}
N -110 340 -110 360 {lab=#net2}
N 270 220 270 320 {lab=OUT}
N 50 160 80 160 {lab=#net3}
N 270 320 270 340 {lab=OUT}
N 80 160 130 160 {lab=#net3}
N -180 80 -180 250 {lab=#net1}
N -100 100 -100 120 {lab=#net1}
N -10 80 -10 250 {lab=#net3}
N 270 90 270 120 {lab=VDD}
N 270 120 270 130 {lab=VDD}
N -110 360 -110 380 {lab=#net2}
N 140 520 140 560 {lab=VSS}
N 60 490 100 490 {lab=PDB}
N 140 420 140 450 {lab=Iref}
N 140 490 170 490 {lab=VSS}
N 170 490 170 550 {lab=VSS}
N 140 550 170 550 {lab=VSS}
N 140 450 140 460 {lab=Iref}
N 140 560 140 580 {lab=VSS}
N 150 30 150 50 {lab=VDD}
N 150 80 170 80 {lab=VDD}
N 170 30 170 80 {lab=VDD}
N 150 30 170 30 {lab=VDD}
N 150 120 150 160 {lab=#net3}
N 90 80 110 80 {lab=PD}
N 270 310 440 310 {lab=OUT}
N 270 340 270 390 {lab=OUT}
N -250 420 80 420 {lab=Iref}
N 130 160 190 160 {lab=#net3}
N 170 -20 230 -20 {lab=VDD}
N 150 110 150 120 {lab=#net3}
N 150 -20 150 30 {lab=VDD}
N 170 580 230 580 {lab=VSS}
N 80 420 230 420 {lab=Iref}
N 510 -70 510 -40 {lab=VDD}
N 510 90 550 90 {lab=VSS}
N 550 90 550 150 {lab=VSS}
N 510 150 550 150 {lab=VSS}
N 510 -10 540 -10 {lab=VDD}
N 540 -70 540 -10 {lab=VDD}
N 510 -70 540 -70 {lab=VDD}
N 510 40 510 60 {lab=PDB}
N 510 120 510 150 {lab=VSS}
N 510 -80 510 -70 {lab=VDD}
N 510 20 510 40 {lab=PDB}
N 510 150 510 180 {lab=VSS}
N 440 -10 470 -10 {lab=PD}
N 440 -10 440 90 {lab=PD}
N 440 90 470 90 {lab=PD}
N 510 -90 510 -80 {lab=VDD}
N 510 -110 510 -90 {lab=VDD}
N 390 40 440 40 {lab=PD}
N 510 40 590 40 {lab=PDB}
N 280 650 370 650 {lab=OUT}
N 370 640 370 650 {lab=OUT}
C {PMOS_MIN.sym} -50 50 0 0 {name=M7 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} -140 50 0 1 {name=M8 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} -220 280 0 0 {name=M9 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 30 280 0 1 {name=M10 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 230 420 0 0 {name=M11 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=6}
C {PMOS_MIN.sym} 230 160 0 0 {name=M12 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=6}
C {ipin.sym} -360 -20 0 0 {name=p5 lab=VDD}
C {iopin.sym} 440 310 0 0 {name=p7 lab=OUT}
C {ipin.sym} -370 450 0 0 {name=p1 lab=Iref}
C {NMOS_MIN.sym} -150 500 0 0 {name=M1 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} -210 500 0 1 {name=M2 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {lab_pin.sym} -100 280 1 0 {name=l5 sig_type=std_logic lab=VSS}
C {ipin.sym} -280 580 0 0 {name=p2 lab=VSS}
C {cap.sym} 250 220 1 0 {name=C1
m=1
value=140f
footprint=1206
device=ceramic}
C {NMOS_MIN.sym} 100 490 0 0 {name=M5 model=n3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 110 80 0 0 {name=M3 model=p3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 470 -10 0 0 {name=M4 model=p3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 470 90 0 0 {name=M6 model=n3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {lab_pin.sym} 510 -110 1 0 {name=l1 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 510 180 3 0 {name=l4 sig_type=std_logic lab=VSS}
C {ipin.sym} 390 40 0 0 {name=p4 lab=PD}
C {lab_pin.sym} 590 40 2 0 {name=l6 sig_type=std_logic lab=PDB}
C {lab_pin.sym} 60 490 0 0 {name=l7 sig_type=std_logic lab=PDB}
C {lab_pin.sym} 90 80 0 0 {name=l9 sig_type=std_logic lab=PD}
C {ipin.sym} -360 210 0 0 {name=p3 lab=Vin+}
