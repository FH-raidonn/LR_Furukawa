v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 520 460 520 490 {lab=GND}
N 630 460 630 490 {lab=GND}
N 290 460 290 490 {lab=GND}
N 1720 620 1720 650 {lab=VSS}
N 1740 650 1740 670 {lab=VSS}
N 1720 540 1720 580 {lab=OUT}
N 1720 520 1760 520 {lab=OUT}
N 1760 520 1760 580 {lab=OUT}
N 1760 630 1760 650 {lab=VSS}
N 1720 650 1760 650 {lab=VSS}
N 1720 520 1720 540 {lab=OUT}
N 1900 650 1900 680 {lab=GND}
N 1900 550 1900 600 {lab=#net1}
N 1550 310 1580 310 {lab=VDD}
N 920 130 1100 130 {lab=VDD}
N 1100 130 1100 170 {lab=VDD}
N 1100 130 1270 130 {lab=VDD}
N 1270 130 1270 170 {lab=VDD}
N 1270 130 1450 130 {lab=VDD}
N 1550 130 1550 240 {lab=VDD}
N 1580 240 1580 310 {lab=VDD}
N 1550 240 1580 240 {lab=VDD}
N 1270 200 1310 200 {lab=VDD}
N 1310 130 1310 200 {lab=VDD}
N 1060 200 1100 200 {lab=VDD}
N 1060 130 1060 200 {lab=VDD}
N 1180 200 1180 250 {lab=#net2}
N 1100 270 1180 270 {lab=#net2}
N 920 360 1340 360 {lab=Vinp}
N 1340 360 1340 430 {lab=Vinp}
N 1310 430 1340 430 {lab=Vinp}
N 1100 460 1100 490 {lab=#net3}
N 1100 490 1270 490 {lab=#net3}
N 1270 460 1270 490 {lab=#net3}
N 1100 430 1270 430 {lab=VSS}
N 1140 200 1230 200 {lab=#net2}
N 1220 730 1450 730 {lab=VSS}
N 980 430 1060 430 {lab=OUT}
N 960 430 980 430 {lab=OUT}
N 1170 680 1170 730 {lab=VSS}
N 1170 650 1190 650 {lab=VSS}
N 1190 650 1190 700 {lab=VSS}
N 1170 700 1190 700 {lab=VSS}
N 1000 730 1220 730 {lab=VSS}
N 1100 650 1130 650 {lab=Iref}
N 1070 650 1100 650 {lab=Iref}
N 1030 680 1030 730 {lab=VSS}
N 1010 650 1030 650 {lab=VSS}
N 1010 650 1010 700 {lab=VSS}
N 1010 700 1030 700 {lab=VSS}
N 1270 310 1330 310 {lab=#net4}
N 1100 600 1100 650 {lab=Iref}
N 1030 600 1100 600 {lab=Iref}
N 900 600 1030 600 {lab=Iref}
N 1030 600 1030 620 {lab=Iref}
N 1030 570 1030 600 {lab=Iref}
N 1550 340 1550 370 {lab=OUT}
N 1510 130 1550 130 {lab=VDD}
N 1470 310 1510 310 {lab=#net4}
N 1470 310 1470 380 {lab=#net4}
N 1550 600 1550 730 {lab=VSS}
N 1510 730 1550 730 {lab=VSS}
N 1550 570 1570 570 {lab=VSS}
N 1570 570 1570 630 {lab=VSS}
N 1550 630 1570 630 {lab=VSS}
N 800 800 1560 800 {lab=OUT}
N 800 430 800 800 {lab=OUT}
N 800 430 960 430 {lab=OUT}
N 1170 530 1170 620 {lab=#net3}
N 1650 460 1650 790 {lab=OUT}
N 1530 380 1550 380 {lab=OUT}
N 1470 380 1490 380 {lab=#net4}
N 1170 490 1170 510 {lab=#net3}
N 1550 370 1550 470 {lab=OUT}
N 1330 310 1360 310 {lab=#net4}
N 1550 470 1550 490 {lab=OUT}
N 1360 310 1410 310 {lab=#net4}
N 1100 230 1100 400 {lab=#net2}
N 1180 250 1180 270 {lab=#net2}
N 1270 230 1270 400 {lab=#net4}
N 1550 240 1550 270 {lab=VDD}
N 1550 270 1550 280 {lab=VDD}
N 1170 510 1170 530 {lab=#net3}
N 1420 670 1420 710 {lab=VSS}
N 1340 640 1380 640 {lab=PDB}
N 1420 570 1420 600 {lab=Iref}
N 1420 640 1450 640 {lab=VSS}
N 1450 640 1450 700 {lab=VSS}
N 1420 700 1450 700 {lab=VSS}
N 1420 600 1420 610 {lab=Iref}
N 1420 710 1420 730 {lab=VSS}
N 1430 180 1430 200 {lab=VDD}
N 1430 230 1450 230 {lab=VDD}
N 1450 180 1450 230 {lab=VDD}
N 1430 180 1450 180 {lab=VDD}
N 1430 270 1430 310 {lab=#net4}
N 1370 230 1390 230 {lab=PD}
N 1550 460 1720 460 {lab=OUT}
N 1550 490 1550 540 {lab=OUT}
N 1030 570 1360 570 {lab=Iref}
N 1410 310 1470 310 {lab=#net4}
N 1450 130 1510 130 {lab=VDD}
N 1430 260 1430 270 {lab=#net4}
N 1430 130 1430 180 {lab=VDD}
N 1450 730 1510 730 {lab=VSS}
N 1360 570 1510 570 {lab=Iref}
N 1220 -180 1220 -150 {lab=VDD}
N 1220 -20 1260 -20 {lab=VSS}
N 1260 -20 1260 40 {lab=VSS}
N 1220 40 1260 40 {lab=VSS}
N 1220 -120 1250 -120 {lab=VDD}
N 1250 -180 1250 -120 {lab=VDD}
N 1220 -180 1250 -180 {lab=VDD}
N 1220 -70 1220 -50 {lab=PDB}
N 1220 10 1220 40 {lab=VSS}
N 1220 -190 1220 -180 {lab=VDD}
N 1220 -90 1220 -70 {lab=PDB}
N 1220 40 1220 70 {lab=VSS}
N 1150 -120 1180 -120 {lab=PD}
N 1150 -120 1150 -20 {lab=PD}
N 1150 -20 1180 -20 {lab=PD}
N 1220 -200 1220 -190 {lab=VDD}
N 1220 -220 1220 -200 {lab=VDD}
N 1100 -70 1150 -70 {lab=PD}
N 1220 -70 1300 -70 {lab=PDB}
N 1560 800 1650 800 {lab=OUT}
N 1650 790 1650 800 {lab=OUT}
N 630 360 920 360 {lab=Vinp}
N 290 360 290 410 {lab=Vinp}
N 290 360 630 360 {lab=Vinp}
N 1720 460 1830 460 {lab=OUT}
N 1740 460 1740 520 {lab=OUT}
C {voltage.sym} 520 400 0 0 {name=V1 value=0}
C {gnd.sym} 520 490 0 0 {name=l2 lab=GND}
C {gnd.sym} 630 490 0 0 {name=l15 lab=GND}
C {vac.sym} 630 400 0 0 {name=V2 value="1.65 ac 1"}
C {vpulse.sym} 290 400 0 0 {name=V3 value="pulse(0 3.3 500n 500n 500n 3u 6u)"}
C {gnd.sym} 290 490 0 0 {name=l1 lab=GND}
C {code_shown.sym} 810 880 0 0 {name=s1 only_toplevel=false value=
"
VVDD VDD 0 dc 3.3
VVSS VSS 0 dc 0
VPD PD 0 dc 3.3
IIref 0 Iref dc 10u

*VVIN+ VIN+ 0 pulse(0 3.3 100n 1n 1n 200n 400n)

*.probe <alli>
*.meas DC IOUT MAX I(V5) 
*IOUT

.include /home/raidonn/LRCircuit/spicemodel/ocs65_stl_n3_typ.para
.include /home/raidonn/LRCircuit/spicemodel/ocs65_stl_p3_typ.para

.control
save all

*dc V4 0 3.3 0.01
*IOUT

*ac dec 10 1k 1g
*phasetime

tran 1n 6u
*SlewRate

*plot V(Vinp) V(OUT)
*SlewRate

*plot I(V5)
*IOUT

*plot db(OUT/(OUT-Vinp)) ph(OUT/(OUT-Vinp))*180/3.14

write "Opamp_ACsim.raw"

.endc"
}
C {res.sym} 1750 570 0 0 {name=R2
value=1meg
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 1740 670 3 0 {name=l14 sig_type=std_logic lab=VSS}
C {cap.sym} 1710 580 0 0 {name=C4
m=1
value=1p
footprint=1206
device=ceramic}
C {voltage.sym} 1900 590 0 0 {name=V4 value=3.3}
C {gnd.sym} 1900 680 0 0 {name=l4 lab=GND}
C {voltage.sym} 1680 410 3 0 {name=V5 value=0}
C {PMOS_MIN.sym} 1230 200 0 0 {name=M4 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 1140 200 0 1 {name=M6 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 1060 430 0 0 {name=M13 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 1310 430 0 1 {name=M14 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 1510 570 0 0 {name=M15 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 1510 310 0 0 {name=M16 model=p3.0 w=20u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {ipin.sym} 920 130 0 0 {name=p6 lab=VDD}
C {iopin.sym} 1820 460 0 0 {name=p8 lab=OUT}
C {ipin.sym} 910 600 0 0 {name=p9 lab=Iref}
C {NMOS_MIN.sym} 1130 650 0 0 {name=M17 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 1070 650 0 1 {name=M18 model=n3.0 w=10u l=1u as=0 ps=0 ad=0 pd=0 m=1}
C {lab_pin.sym} 930 360 1 0 {name=l6 sig_type=std_logic lab=Vinp}
C {lab_pin.sym} 1180 430 1 0 {name=l7 sig_type=std_logic lab=VSS}
C {ipin.sym} 1000 730 0 0 {name=p10 lab=VSS}
C {cap.sym} 1530 370 1 0 {name=C2
m=1
value=1p
footprint=1206
device=ceramic}
C {lab_pin.sym} 910 430 3 0 {name=l9 sig_type=std_logic lab=Vinm}
C {NMOS_MIN.sym} 1380 640 0 0 {name=M19 model=n3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 1390 230 0 0 {name=M20 model=p3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {PMOS_MIN.sym} 1180 -120 0 0 {name=M21 model=p3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {NMOS_MIN.sym} 1180 -20 0 0 {name=M22 model=n3.0 w=3.5u l=0.35u as=0 ps=0 ad=0 pd=0 m=1}
C {lab_pin.sym} 1220 -220 1 0 {name=l10 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1220 70 3 0 {name=l11 sig_type=std_logic lab=VSS}
C {ipin.sym} 1100 -70 0 0 {name=p11 lab=PD}
C {lab_pin.sym} 1300 -70 2 0 {name=l12 sig_type=std_logic lab=PDB}
C {lab_pin.sym} 1340 640 0 0 {name=l13 sig_type=std_logic lab=PDB}
C {lab_pin.sym} 1370 230 0 0 {name=l16 sig_type=std_logic lab=PD}
